# Keil uVision project M600.uvprojx, settings and files
target Development (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M600 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\BSP;..\User;..\User\DRV;..\User\APP;..\User\SEGGER;..\Libraries\FWlib\src;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\CMSIS;..\User\APP;..\User\LIB;..\User\SEGGER;..\User\BackTrace
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: bsp_adc.c bsp_dac.c bsp_gpio.c bsp_i2c.c bsp_iwdg.c bsp_tim.c bsp_usart.c bsp_delay.c bsp_SI5351.c
  group DRV
    ../User/DRV/: drv_adc.c drv_dac.c drv_delay.c drv_init.c drv_iodevice.c drv_memory.c drv_si5351.c drv_tim.c drv_usart.c drv_wdg.c drv_soft_i2c.c drv_24c02.c
  group User
    ../User/: delay.c main.c stm32f103_it.c
  group Start_Up
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group APP
    ../User/APP/: app_comm.c app_handcomm.c app_memory.c app_negprsheat.c app_radiofreq.c app_shockwave.c app_system.c app_treatmgr.c app_ultrasound.c app_led.c
  group LIB
    ../User/SEGGER/: log.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../User/BackTrace/: cm_backtrace.c
    ../User/BackTrace/fault_handler/keil/: cmb_fault.S
    ../User/LIB/: lib_ringbuffer.c lib_aiic.c
